Commit message: working moving swing arm

File: conveyorbelt_gazebo/urdf/box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link box: mass 0.1 -> 0.01
